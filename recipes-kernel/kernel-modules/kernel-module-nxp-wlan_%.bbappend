module_conf_moal = "options moal mod_para=nxp/wifi_prod_params.conf"

KERNEL_MODULE_PROBECONF += "moal"
