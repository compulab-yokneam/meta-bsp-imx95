# NetworkManager owns Ethernet configuration in CompuLab images.
PACKAGECONFIG:remove = "dhcp-ethernet"
