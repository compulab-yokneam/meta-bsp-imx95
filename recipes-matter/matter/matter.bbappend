IMX_MATTER_SRC = "gitsm://github.com/NXP/matter.git;protocol=https"
deltask checkout_submodules
