# NetworkManager provides DHCP configuration.
SYSTEMD_AUTO_ENABLE:${PN} = "disable"
