SRCREV = "e5c9a169d7b7a441a20d2cf10a9752e249b71cff"

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-hide-debug-prints.patch"

